// Aritmetic.cpp: Implementierung der Klasse CArithmetic.
//
//////////////////////////////////////////////////////////////////////

#include "stdafx.h"
#include "Aritmetic.h"


#ifdef _DEBUG
#undef THIS_FILE
static char THIS_FILE[]=__FILE__;
#define new DEBUG_NEW
#endif

#pragma warning (disable: 4996)


//////////////////////////////////////////////////////////////////////
// Konstruktion/Destruktion
//////////////////////////////////////////////////////////////////////
const char *CArithmetic::gm_UnaryFkt[] = 
{
   "sin" ,  "cos" ,  "tan" ,          // 101, 102, 103
  "asin" , "acos" , "atan" ,          // 104, 105, 106
   "sinh",  "cosh",  "tanh",          // 107, 108, 109
  "asinh", "acosh", "atanh",          // 110, 111, 112
  "abs"  ,"floor" , "ceil" , "round", // 113, 114, 115, 116
  "ln"   ,"log"   , "sqrt" ,          // 117, 118, 119
  "phase", "real", "imag",            // 120,121, 122
  NULL
};

const char *CArithmetic::gm_BinaryFkt[] = 
{
   "logb",                            // 150
   "hypot",                           // 151
   "bess1",                           // 152
   "bess2",                           // 153
   "atan2",                           // 154
   "roundto",                         // 155
   "complex",                         // 156
   "complexAP",                       // 157
   "min",                             // 158
   "max",                             // 159

   NULL
};


#ifndef IDS_CONST_EULER
 #define IDS_CONST_EULER         0
#endif
#ifndef IDS_CONST_PI
 #define IDS_CONST_PI            0
#endif
#ifndef IDS_CONST_PERMEABILITY
 #define IDS_CONST_PERMEABILITY  0
#endif
#ifndef IDS_CONST_DIELEKTRICITY
 #define IDS_CONST_DIELEKTRICITY 0
#endif
#ifndef IDS_CONST_PLANK
 #define IDS_CONST_PLANK         0
#endif
#ifndef IDS_CONST_BOLTZMANN
 #define IDS_CONST_BOLTZMANN     0
#endif
#ifndef IDS_CONST_UNIT_CHARGE
 #define IDS_CONST_UNIT_CHARGE   0
#endif
#ifndef IDS_CONST_AVOGADRO
 #define IDS_CONST_AVOGADRO      0
#endif
#ifndef IDS_CONST_LIGHT_VELOCITY
 #define IDS_CONST_LIGHT_VELOCITY 0
#endif
#ifndef IDS_CONST_FINE_STRUC
 #define IDS_CONST_FINE_STRUC    0
#endif
#ifndef IDS_CONST_GRAVITY
 #define IDS_CONST_GRAVITY       0
#endif

#ifndef M_E
  #define M_E 2.71828182845904523536
#endif
const sConstants CArithmetic::gm_constants[] = 
{
    {"~e", IDS_CONST_EULER, M_E},          // Eulersche Zahl
    {"~pi", IDS_CONST_PI, M_PI},                        // Zahl PI
    {"~µ0", IDS_CONST_PERMEABILITY, 12.566370614e-7},   // Permeabilität des Vakuums
    {"~e0", IDS_CONST_DIELEKTRICITY, 8.854187817e-12},  // Dielektrizitätskonstante des Vakuums
    {"~h", IDS_CONST_PLANK, 6.6260755E-34 },            // Plancksches Wirkungsquantum    
    {"~k", IDS_CONST_BOLTZMANN, 1.380658e-23  },        // Boltzmannsche Konstante 
    {"~ec", IDS_CONST_UNIT_CHARGE, 1.60217733e-19  },   // Elementarladung
    {"~NA", IDS_CONST_AVOGADRO, 6.0221367e23  },        // Avogadrosche Zahl 
    {"~c", IDS_CONST_LIGHT_VELOCITY, 2.99792458e8  },   // Lichtgeschwindigkeit
    {"~alpha", IDS_CONST_FINE_STRUC, 1 / 137.0359895 }, // Feinstrukturkonstante
    {"~me", 1, 9.1093897e-31 },     // Elektronenruhemasse
    {"~mp", 1, 1.6726231e-27 },     // Protonenruhemasse  
    {"~mn", 1, 1.6749286e-27 },     // Neutronenruhemasse
    {"~µB", 1, 9.2740154e-24 },     // Bohrsches Magneton
    {"~µN", 1, 5.0507866e-27 },   // Kernmagneton  
    {"~ge", 1, 2.002319304386},     // g-Faktor des freien Elektrons 
    {"~µe", 1, -9.2847701e-24 },    // magnetisches Moment des Elektrons
    {"~µp", 1, 1.41060761e-26 },    // magnetisches Moment des Protons 
    {"~amu", 1, 1.66054e-27 },      // Einheit der Atommasse 
    {"~a0", 1, 5.29177e-11 },       // Bohrscher Radius 
    {"~re", 1, 2.81792e-15 },       // Elektronenradius 
    {"~R", 1, 8.31451 },            // Gaskonstante
    {"~Vmol", 1, 22.41383},         // Molvolumen 
    {"~F", 1, 9.64846e4},           // Faradaysche Konstante
    {"~G", IDS_CONST_GRAVITY, 9.80665 },// Gravitationskonstante
    {"~g", 1, 9.80665 },            // Erdbeschleunigung 
    {NULL, 0, 0}
};

double CArithmetic::gm_AngleTo   = 1.0;
double CArithmetic::gm_AngleFrom = 1.0;
const double CArithmetic::gm_d2PI = 2.0*M_PI;

CArithmetic::CArithmetic():
    m_nError(IDE_AR_NOEQUATION),
    m_nNumVar(0),
    m_pVar(NULL),
    m_pP(NULL)
{
   TCHAR szDecimal_t[8] = _T(".");
   _stprintf(szDecimal_t, _T("%.1f"), 1.1);
   m_szDecimal[0] = (char)szDecimal_t[1];
   m_szDecimal[1] = 0;
   m_szDecimal[2] = (m_szDecimal[0] == '.') ? ',' : ';';
   m_szDecimal[3] = 0;
}

CArithmetic::~CArithmetic()
{
   Delete();
}

Complex CArithmetic::Calculate()
{
   Complex dResult = 0;
   if (m_pP)
   {
      m_nError = 0;
      try
      {
         dResult = calc(m_pP);
      }
      catch (int nError)
      {
         m_nError = nError;
      }
   }
   else m_nError  = IDE_AR_NOEQUATION;

   return dResult;
}

void CArithmetic::Delete()
{
   m_pP      = deletearithmnodes(m_pP);
   m_pVar    = deletevariables(m_pVar);
   m_nNumVar = 0;
   m_nError  = IDE_AR_NOEQUATION;
}

DWORD CArithmetic::SetEquation(const char *eq)
{
   int         i     = 0,                                      // Gleichungsstringindex
               j     = 0,                                      // Variablen-, Funktions- oder Zahlenstringindex
               nBinaryFunction = 0,                            // Funktion mit zwei Argumenten
               ch = 0, k, lastch = 0;                                          // Einzelbuchstabe des Gleichungsstrings
   Complex     temp  = 0;
   char        level,                                          // Operatorpriorität
               str[128] = "";                                   // Variablen-, Funktions- oder Zahlenstring
   SArithmaNode number, constnull,                             // Einfügeknoten für Zahlen, Konstanten, Variablen
               binaryoperator, unaryoperator;                  // und Operatoren
   SVarNode    SVarNode;                                       // Einfügeknoten für Variablennamen
   Delete();                                                   // Löschen der alten Gleichungswerte

   if ((!eq) || (!strlen(eq)))                                 // Prüfen des Eingabegleichungsstrings
   {
      m_nError = IDE_AR_NOEQUATION;
      return 1;
   }

   memset(&number, 0, sizeof(SArithmaNode));                   // Vorbelegung für Zahl
   number.level         = IDL_AR_NUMBER;                       // eine Zahl hat immer den Zahlen Level

   memset(&binaryoperator, 0, sizeof(SArithmaNode));           // Vorbelegung für Operator
   binaryoperator.brace = 0;                                   // Operatoren haben immer die aktuelle Klammerebene

   memset(&unaryoperator, 0, sizeof(SArithmaNode));            // Vorbelegung für Funktion
   unaryoperator.level  = IDL_AR_FUNCTION;

   memset(&constnull, 0, sizeof(SArithmaNode));                // Vorbelegung für die Konstante 0
   constnull.level      = IDL_AR_NUMBER;
   constnull.coperator  = IDO_AR_CONST;                        // 0 ist eine Konstante
   SVarNode.pszname     = "§0";
   SVarNode.pvalue      = &temp;                               // für die Vorbelegung der Konstanten
   m_pVar               = insertvar(m_pVar, &SVarNode);        // Variable 0 einfügen
   constnull.pvalue     = SVarNode.pvalue;
   constnull.pszname    = SVarNode.pszname;

   do 
   {
      lastch = ch;
      ch = eq[i++];
      level = 0;
      switch(ch)
      {
         case '§' : case '""': case '?': case '$':  case ';': case ':': case '#':
            m_nError = IDE_AR_INVALIDCHARACTER;
            return MAKELPARAM(i-1, i);
         case '\n':
         case '\r':
         case ' ' : break;
         case ')' : binaryoperator.brace--;
            break;
         case '(' : binaryoperator.brace++;
         case '^' :                                   level++; // Level = 5
         case '/' : case '%' :                        level++; // Level = 4
         case '*' :            case '&' :             level++; // Level = 3
         case '-' :
            if (   ch == '-' 
                && (lastch=='e' || lastch == 'E'))
            {
                str[j++] = ch;
                break;
            }
            else                                      level++; // Level = 2   // Achtung nachträglich geändert !
         case '+' : case '|' : case '!' :                      // Level = 1   // Testen
         case '>' : case '<' : case '=' :
            if (   ch == '+' 
                && (lastch=='e' || lastch == 'E'))
            {
                str[j++] = ch;
                break;
            }
            else                                      level++; // Level = 2   // Achtung nachträglich geändert !
         case ',' :
            if (ch == ',')
            {
               if (nBinaryFunction == 0)
               {
                  m_nError = IDE_AR_DECIMAL_POINT;
                  return MAKELPARAM(i-1, i);
               }
            }
         case  0  :
            if (j)                                             // Wenn Variablen-, Funktions- oder Zahlenstring gefüllt ist
            {
               for (k=0; k<j; k++)                             // Zeichenkette analysieren
                  if (!isdigit(str[k]) && str[k] != '.' && str[k] != 'e'&& str[k] != '-' && str[k] != '+')
                      break;
               if (k==j)                                       // ist es eine Zahl ?
               {
                  char *ptr = strstr(str, ".");                // Dezimalzeichen korrigieren
                  if (ptr) ptr[0]  = m_szDecimal[0];
                  number.pvalue    = new Complex;              // Speicher allocieren
                  number.pvalue[0] = atof(str);                // String in Zahlenwert umwandeln
                  number.coperator = IDO_AR_NUM;               // als numerische Konstante deklarieren
                  number.pszname   = NULL;                     // einen Namen hat sie nicht
               }
               else if (ch == '(')                             // ist eine Klammer hinter der Zeichenkette
               {
                  unaryoperator.coperator = getFuncIndex(str); // Ist es eine Funktion
                  if (!unaryoperator.coperator) {m_nError = IDE_AR_NOFUNCTION; return MAKELPARAM(i-j-1,i-1);}
                  if (unaryoperator.coperator < IDO_AR_LOGB)
                  {
                     constnull.brace = binaryoperator.brace;   // die 0 befindet sich in der Funktionsklammer
                     m_pP = insert(m_pP, &constnull);          // Einfügen der Konstante 0
                                                               // die Klammerebene der Funktion ist die vor der Funktionsklammer
                     unaryoperator.brace = binaryoperator.brace - 1;
                     m_pP = insert(m_pP, &unaryoperator);      // Einfügen des unären Operators
                  }
                  else
                  {
                     nBinaryFunction = unaryoperator.coperator;
                  }
                  j = 0;
                  str[j] = 0;
                  break;                                       // danach nächsten Ausdruck suchen
               }
               else                                            // sonst ist es eine Variable oder eine Konstante
               {
                  SVarNode.pvalue = &temp;                     // Adresse von temp für Vorbelegung des Wertes der Variablen oder der Konstanten
                  temp.realteil   = getConstValue(str);        // Ist es eine Konstante
                  if (temp.realteil == 0) number.coperator = IDO_AR_VAR;// Nein, als Variable deklarieren
                  else                                         // Ja
                  {
                     number.coperator = IDO_AR_CONST;          // als Konstante deklarieren
                     for (k=j; k>0; k--) str[k] = str[k-1];
                     str[0] = '§';                             // das Paragraphenzeichen als Indikator für Konstanten
                  }
                  SVarNode.pszname = str;                      // Variablennamen übergeben
                  m_pVar = insertvar(m_pVar, &SVarNode);       // Variable in Liste eintragen
                  number.pvalue    = SVarNode.pvalue;          // Zeiger auf Variable übergeben
                  number.pszname   = SVarNode.pszname;         // Zeiger auf Variablennamen übergeben
               }
               j = 0;                                          // nach Wandlung auf 0 setzen
               str[j] = 0;

               if (number.brace < binaryoperator.brace)        // wenn die Zahl eigentlich schon in der Klammer ist
                  number.brace = binaryoperator.brace;         // Klammerebene für die Zahl setzen

               m_pP = insert(m_pP, &number);                   // Einfügen der Zahl oder Variable bei binären Operatoren

               number.brace = binaryoperator.brace;            // nach dem Einfügen der Zahl Klammerebene aktualisieren

               if (ch == 0) break;                             // ist es das letzte Zeichen : Ende
               if (ch == ',')
               {
                  ch = nBinaryFunction;
                  nBinaryFunction = 0;
               }

               binaryoperator.level     = level;               // Struktur aktualisieren
               binaryoperator.coperator = ch;
               m_pP = insert(m_pP, &binaryoperator);           // Einfügen des binären Operators
            }
            else if ((ch == '-') || (ch == '!'))               // Ein Minuszeichen hinter einem Operator ist eine Negation
            {
               constnull.brace = binaryoperator.brace;         // Klammerebene aktualisieren
               m_pP = insert(m_pP, &constnull);                // Einfügen der Zahl 0
               unaryoperator.coperator = ch;                   // Struktur aktualisieren
               unaryoperator.brace     = binaryoperator.brace;
               m_pP = insert(m_pP, &unaryoperator);            // Einfügen des unären Operators '-'
            }
            else if (ch == '(');                               // Klammern sind erlaubt
            else {m_nError = IDE_AR_OPERATOR; return MAKELPARAM(i-1, i);} // sonst Fehler

            break;
         default :
            str[j++] = ch;
            str[j]   = 0;
            break;
      }
   }
   while (ch != 0);

   if (binaryoperator.brace)
   {
      m_nError = IDE_AR_BRACE;
      return i;
   }
   m_nError = IDE_AR_OK;
   return 0;
}

SArithmaNode * CArithmetic::newnode(SArithmaNode *pin)
{
   SArithmaNode *p;
   p = new SArithmaNode;
   if (!p) return NULL;
   memcpy(p, pin, sizeof(SArithmaNode));
   return p;
}

SArithmaNode * CArithmetic::insert(SArithmaNode *p, SArithmaNode *pin)
{
   SArithmaNode *q;

   if (!p)                                                     // Fall (1)
   {
      p = newnode(pin);                                        // neues Element eingefügen
   }
   else if (pin->coperator<=IDO_AR_CONST)                      // ist es ein numerischer Wert
   {
      if      (!p->pleft)                                      // Fall (2)
      {
         p->pleft =insert(p->pleft, pin);                      // linkes Blatt zuerst belegen
      }
      else if (!p->pright)                                     // Fall (3)
      {
         p->pright=insert(p->pright, pin);                     // dann rechtes Blatt
      }
      else                                                     // Fall (4)
      {
         p->pright=insert(p->pright, pin);                     // weitersuchen
      }
   }
   else                                                        // wenn es ein Operator ist
   {
      if (*((DWORD*)pin) <= *((DWORD*)p))                      // Fall (5)
      {                                                        // wenn der Rang niedriger als der Rang im Knoten oder gleich ist  
         q = newnode(pin);                                     // Knoten dazwischensetzen
         q->pleft = p;
         return q;
      }
      else                                                     // Fall (6)
      {
         p->pright=insert(p->pright, pin);                     // weitersuchen
      }  
   }
   return p;
}

Complex CArithmetic::calc(SArithmaNode *p)
{
   Complex a, b;
   bool    aComplex = false, bComplex = false;

   if (/*(p->coperator>=IDO_AR_NUM)&& "((DWORD) >= 0)"*/       // ist es ein numerischer Wert
       (p->coperator<=IDO_AR_CONST)) return p->pvalue[0];

   a = calc(p->pleft);
   if (a.imagteil != 0) aComplex = true;
   b = calc(p->pright);
   if (b.imagteil != 0) bComplex = true;

   if (aComplex || bComplex)                                   // ein operator Komplex
   {
      switch(p->coperator)
      {
         case '+': return a+b;                                 // binäre Operatoren
         case '-': return a-b;
         case '*': return a*b;
         case '/':
            if (bComplex) { if (Betrag(b)  !=0) return a/b;}
            else          { if (b.realteil !=0) return a/b.realteil;}
            throw (int)IDE_AR_ZERO;
         case  IDO_AR_ABS:                                     // unäre und binäre Funktionen
            if (bComplex)        return Complex(Betrag(b), 0);
            else                 return Complex(fabs(b.realteil), 0);
         case  IDO_AR_SQRT:      return Sqrt(b);
         case '^':
            if (bComplex)        return Pow(a, b);
            else                 return Pow(a, b.realteil);
         case IDO_AR_LOG:        return Logn(b);
         case IDO_AR_LOG10:      return Logb(10.0, b);
         case IDO_AR_LOGB:       return Logb(a, b);
         case IDO_AR_COMPLEX:    return Complex(a.realteil, b.realteil);
         case IDO_AR_COMPLEX_AP: return ComplexAP(a.realteil, b.realteil*gm_AngleFrom);
         case IDO_AR_HYPOT:      return Hypot(a, b);
         case IDO_AR_PHASE:      return PhaseRAD(b)*gm_AngleFrom;
         case IDO_AR_REAL:       return Complex(b.realteil, 0);
         case IDO_AR_IMAG:       return Complex(b.imagteil, 0);
         case IDO_AR_ASINH:      return Asinh(b);
         case IDO_AR_ACOSH:      return Acosh(b);
         case IDO_AR_ATANH:      if (b!=Complex(1, 0)) return Atanh(b);
            throw (int)IDE_AR_OUTOFRANGE;
         case IDO_AR_TAN:        if ((-355 <= b.imagteil) && (b.imagteil <= 355)) return Tan(b);
         case IDO_AR_TANH:       if ((-355 <= b.realteil) && (b.realteil <= 355)) return Tanh(b);
            throw (int)IDE_AR_OUTOFRANGE;
         case IDO_AR_SIN:        if ((-710 <= b.imagteil) && (b.imagteil <= 710)) return Sin(b);
         case IDO_AR_COS:        if ((-710 <= b.imagteil) && (b.imagteil <= 710)) return Cos(b);
         case IDO_AR_SINH:       if ((-710 <= b.realteil) && (b.realteil <= 710)) return Sinh(b);
         case IDO_AR_COSH:       if ((-710 <= b.realteil) && (b.realteil <= 710)) return Cosh(b);
            throw (int)IDE_AR_OUTOFRANGE;

         default:
            throw (int)IDE_AR_NO_COMPLEX_IMPL;
/*
         case  IDO_AR_ATAN  : return atan(b);
         case  IDO_AR_ASIN  : if ((-1 <= b) && (b <= 1)) return asin(b);
         case  IDO_AR_ACOS  : if ((-1 <= b) && (b <= 1)) return acos(b);
            throw (int)IDE_AR_OUTOFRANGE;
            break;

         throw (int)IDE_AR_OUTOFRANGE;
*/
      }
   }
   else
   {
      switch(p->coperator)
      {
         case '+': return Complex(a.realteil+b.realteil, 0);                                    // binäre Operatoren
         case '-': return Complex(a.realteil-b.realteil, 0);
         case '*': return Complex(a.realteil*b.realteil, 0);
         case '&': return Complex(((a.realteil != 0) && (b.realteil != 0)) ? 1 : 0, 0);
         case '|': return Complex(((a.realteil != 0) || (b.realteil != 0)) ? 1 : 0, 0);
         case '<': return Complex((a.realteil <  b.realteil) ? 1 : 0, 0);
         case '>': return Complex((a.realteil >  b.realteil) ? 1 : 0, 0);
         case '=': return Complex((a.realteil == b.realteil) ? 1 : 0, 0);
         case '/': if (b.realteil !=0) return Complex(a.realteil/b.realteil, 0);
         case '%': if (b.realteil !=0) return Complex(fmod(a.realteil, b.realteil), 0);
            throw (int)IDE_AR_ZERO;
            break;
         case '^': 
            if ((a.realteil < 0) && (fmod(b.realteil, 1) != 0)) return Pow(a, b.realteil);
            else                                                return Complex(pow(a.realteil, b.realteil), 0);
         case '!':            return Complex((b.realteil != 0) ? 0 : 1, 0);// unäre und binäre Funktionen
         case  IDO_AR_SIN   : return Complex(sinEx(b.realteil*gm_AngleTo), 0);
         case  IDO_AR_COS   : return Complex(cos(b.realteil*gm_AngleTo), 0);
         case  IDO_AR_TAN   : return Complex(tan(b.realteil*gm_AngleTo), 0);
         case  IDO_AR_HYPOT : return Complex(_hypot(a.realteil, b.realteil), 0);

         case  IDO_AR_ATAN  : return Complex(atan(b.realteil)*gm_AngleFrom, 0);
         case  IDO_AR_ASIN  : if ((-1 <= b.realteil) && (b.realteil <= 1)) return Complex(asin(b.realteil)*gm_AngleFrom, 0);
         case  IDO_AR_ACOS  : if ((-1 <= b.realteil) && (b.realteil <= 1)) return Complex(acos(b.realteil)*gm_AngleFrom, 0);
            throw (int)IDE_AR_OUTOFRANGE;
            break;
         case  IDO_AR_TANH  : return Complex(tanh(b.realteil), 0);
         case  IDO_AR_SINH  : if ((-710 <= b.realteil) && (b.realteil <= 710)) return Complex(sinh(b.realteil), 0);
         case  IDO_AR_COSH  : if ((-710 <= b.realteil) && (b.realteil <= 710)) return Complex(cosh(b.realteil), 0);
            throw (int)IDE_AR_OUTOFRANGE;
            break;
         case  IDO_AR_ATANH : return Complex(atanh(b.realteil), 0); break;
         case  IDO_AR_ASINH : return Complex(asinh(b.realteil), 0); break;
         case  IDO_AR_ACOSH : return Complex(acosh(b.realteil), 0); break;

         case  IDO_AR_ABS   : return Complex(fabs(b.realteil), 0);
         case  IDO_AR_FLOOR : return Complex(floor(b.realteil), 0);
         case  IDO_AR_CEIL  : return Complex(ceil(b.realteil), 0);
         case  IDO_AR_ROUND : return Complex(round(b.realteil), 0);

         case  IDO_AR_SQRT  : if   (b.realteil >= 0) return Complex(sqrt(b.realteil), 0);
                              else                   return Complex(0, sqrt(-b.realteil));
         case  IDO_AR_LOG   : if  (b.realteil >  0)  return Complex(log(b.realteil), 0);
         case  IDO_AR_LOG10 : if  (b.realteil >  0)  return Complex(log10(b.realteil), 0);
         case  IDO_AR_LOGB  : if ((b.realteil >  0) && (a.realteil >  0))
                                 return Complex(logb(a.realteil, b.realteil), 0);
         case  IDO_AR_ATAN2 : return Complex(atan2(a.realteil,b.realteil)*gm_AngleFrom, 0);
         case  IDO_AR_BESS1 :
         {
            int n = (int)round(a.realteil);
            if      (n==0) return Complex(_j0(b.realteil), 0);
            else if (n==1) return Complex(_j1(b.realteil), 0);
            else if (n>=2) return Complex(_jn(n, b.realteil), 0);
            throw (int)IDE_AR_OUTOFRANGE;
         }
         case  IDO_AR_BESS2 :
         {
            int n = (int)round(a.realteil);
            if      (n==0) return Complex(_y0(b.realteil), 0);
            else if (n==1) return Complex(_y1(b.realteil), 0);
            else if (n>=2) return Complex(_yn(n, b.realteil), 0);
            throw (int)IDE_AR_OUTOFRANGE;
         }
         case IDO_AR_ROUNDTO:    return Complex(roundto(a.realteil, b.realteil), 0);
         case IDO_AR_COMPLEX:    return Complex(a.realteil, b.realteil);
         case IDO_AR_COMPLEX_AP: return ComplexAP(a.realteil, b.realteil*gm_AngleTo);
         case IDO_AR_PHASE:      case IDO_AR_IMAG: return Complex(0, 0);
         case IDO_AR_MIN:        return Complex(min(a.realteil, b.realteil), 0);
         case IDO_AR_MAX:        return Complex(max(a.realteil, b.realteil), 0);
      }
   }
   return 1;
}

void CArithmetic::Show(CTreeCtrl *ptc)
{
   TV_INSERTSTRUCT tv_is;
   if (!ptc->DeleteAllItems()) return;
   memset(&tv_is, 0, sizeof(TV_INSERTSTRUCT));
   tv_is.hParent      = TVI_ROOT;
   tv_is.hInsertAfter = TVI_LAST;
   tv_is.item.mask    = TVIF_TEXT;

   show(m_pP, &tv_is, ptc);
}

void CArithmetic::show(SArithmaNode *p, TV_INSERTSTRUCT *ptv_is, CTreeCtrl *ptc)
{
   HTREEITEM      hparent;
   char           text[40];

   if (!p) return;
   switch (p->coperator)
   {
      case  IDO_AR_NUM : 
         sprintf(text, "%.2f, %x", p->pvalue[0], *((DWORD*)p));
         break;
      case  IDO_AR_VAR : case  IDO_AR_CONST :
         sprintf(text, "%s, %x", p->pszname, *((DWORD*)p));
         break;
      case '+': case '-': case '*': case '&': case '|': case '<':
      case '>': case '=': case '/': case '%': case '^': case '!':
         sprintf(text, "Op:(%c), %x", p->coperator, *((DWORD*)p));
         break;
      default:
         if      ((p->coperator >= IDO_AR_SIN) && (p->coperator <= IDO_AR_IMAG))
            sprintf(text, "%s(x), %x", gm_UnaryFkt[p->coperator - IDO_AR_SIN], *((DWORD*)p));
         else if ((p->coperator >= IDO_AR_LOGB) && (p->coperator <= IDO_AR_MAX))
            sprintf(text, "%s(x,y), %x", gm_BinaryFkt[p->coperator - IDO_AR_LOGB], *((DWORD*)p));
   }
   
   //ptv_is->item.pszText = text;
   hparent = ptc->InsertItem(ptv_is);

   if (!hparent) return;
   ptv_is->hParent = hparent;
   show(p->pleft, ptv_is, ptc);
   ptv_is->hParent = hparent;
   show(p->pright, ptv_is, ptc);
}

SArithmaNode *CArithmetic::deletearithmnodes(SArithmaNode *p)
{
   if (!p) return NULL;
   if ((!p->pleft) && (!p->pright))
   {
      if ((p->pvalue) && (p->coperator == IDO_AR_NUM))      // nur löschen, wenn es eine numerische Konstante ist
         delete p->pvalue;
      delete p;
   }
   else
   {
      p->pleft  = deletearithmnodes(p->pleft);
      p->pright = deletearithmnodes(p->pright);
      delete p;
   }
   return NULL;
}

SVarNode * CArithmetic::insertvar(SVarNode *p, SVarNode *pin)
{
   int len;
   if (!p)
   {
      if ((pin->pszname) && (len = strlen(pin->pszname)))      // nur, wenn eine Variable vorhanden ist
      {
         p = new SVarNode;                                     // neuen Knoten erzeugen
         len++;
         p->pszname   = new char[len];
         strcpy(p->pszname, pin->pszname);                     // Variablennamen speichern
         p->pvalue    = new Complex;                           // Speicher für Variablenwert allocieren
         p->pvalue[0] = pin->pvalue[0];                        // Variablenwert belegen aus der Struktur
         pin->pvalue  = p->pvalue;                             // Adressen über die Struktur zurückgeben
         pin->pszname = p->pszname;
         p->pleft     = NULL;
         p->pright    = NULL;
         m_nNumVar++;                                          // Variablen Zählen
      }
      else return NULL;                                        // sonst 0 zurückgeben
   }
   else
   {
      len = strcmp(p->pszname, pin->pszname);                  // Variablennamen vergleichen
      if      (len < 0) p->pleft  = insertvar(p->pleft,  pin); // links in den Baum einsortieren
      else if (len > 0) p->pright = insertvar(p->pright, pin); // rechts in den Baum einsortieren
      else
      {
         pin->pvalue  = p->pvalue;                             // Adressen über die Struktur zurückgeben
         pin->pszname = p->pszname;
      }
   }
   return p;
}

SVarNode * CArithmetic::deletevariables(SVarNode *p)
{
   if (!p) return NULL;
   if (p->pvalue)  delete   p->pvalue;
   if (p->pszname) delete[] p->pszname;
   p->pleft  = deletevariables(p->pleft);
   p->pright = deletevariables(p->pright);
   delete p;
   return NULL;
}

char * CArithmetic::GetVarName(int n)
{
   return getvarname(m_pVar, n);
}
char * CArithmetic::getvarname(SVarNode *p, int& n)
{
   char *psz = NULL;
   if (!p)                           return psz;
   if (n==0)
   {
      if (p->pszname[0]!='§')        return p->pszname;
      else { n = -1;                 return psz;}
   }
   if (n<0)                          return psz;
   n--;
   psz = getvarname(p->pleft,  n);
   if (psz)                          return psz;
   psz = getvarname(p->pright, n);
   return psz;
}

Complex * CArithmetic::GetVarAdress(const char *psz)
{
   if (!psz)         return NULL;
   if (!strlen(psz)) return NULL;
   return getvaradress(m_pVar, psz);
}

Complex * CArithmetic::getvaradress(SVarNode *p, const char * psz)
{
   int comp;
   if (!p)   return NULL;
   comp = strcmp(p->pszname, psz);                  // Variablennamen vergleichen
   if (comp==0)  return p->pvalue;
   if (comp < 0) return getvaradress(p->pleft,  psz);
   if (comp > 0) return getvaradress(p->pright, psz);
   return NULL;
}

int CArithmetic::getFuncIndex(const char *psz)
{
   int i;
   if (!psz)         return 0;
   if (!strlen(psz)) return 0;
   for (i=0; gm_UnaryFkt[i]  != NULL; i++) if (!strcmp(gm_UnaryFkt[i] , psz)) return i+IDO_AR_SIN;
   for (i=0; gm_BinaryFkt[i] != NULL; i++) if (!strcmp(gm_BinaryFkt[i], psz)) return i+IDO_AR_LOGB;
   return 0;
}

double CArithmetic::getConstValue(const char *psz)
{
   int i;
   if (!psz)         return 0;
   if (!strlen(psz)) return 0;
   for (i=0; gm_constants[i].name != NULL; i++) if (!strcmp(gm_constants[i].name, psz)) return gm_constants[i].value;
   return 0;
}

// selbsdefinierte Funktionen
double CArithmetic::logb(double b, double x)
{
   return log(x) / log(b);
}
double CArithmetic::asinh(double x)
{
   return log(x + sqrt(x * x + 1));
}
double CArithmetic::acosh(double x)
{
   if (x < 1.0) throw (int)IDE_AR_OUTOFRANGE;
   return log(x + sqrt(x * x -1));
}
double CArithmetic::atanh(double x)
{
   if ((x <= -1.0) || (x >= 1.0)) throw (int)IDE_AR_OUTOFRANGE;
   return 0.5 * log((1.0 + x) / (1.0 - x));
}
double CArithmetic::acotanh(double x)
{
   if (fabs(x) >= 1.0) throw (int)IDE_AR_OUTOFRANGE;
   return 0.5 * log((1.0 + x) / (1.0 - x));
}
double CArithmetic::round(double dval)
{
   double temp = floor(dval+0.5);
   return temp;
}
double CArithmetic::roundto(double dround, double dval)
{
   if (dround <= 0.0) throw (int)IDE_AR_OUTOFRANGE;
   double dabsval = fabs(dval);
   double drest   = fmod( dabsval, dround) * 2.0;
   double dnum    = floor(dabsval / dround);
   if (drest >= dround) dnum += 1.0;
   dnum *= dround;
   return (dval < 0.0) ? -dnum : dnum;
}
double CArithmetic::sinEx(double dVal)
{
   if (dVal > gm_d2PI*2)
   {
      double dn2PI = floor(dVal/gm_d2PI);
      dVal -= (dn2PI * gm_d2PI);
   }
   return sin(dVal);
}

Complex CArithmetic::Hypot(Complex&a, Complex&b)
{
    return Sqrt(a*a + b*b);
}
